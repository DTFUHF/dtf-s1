# Keil uVision project dtf-s1.uvprojx, settings and files
target dtf-s1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: dtf-s1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;                                          ../Drivers/STM32F0xx_HAL_Driver/Inc;                                          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                          ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                          ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;                                          ../Drivers/CMSIS/Include;                                          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c cc2500.c cc2500_tx_carrier_test.c frsky2way_common.c frsky2way_rx.c frsky2way_rx_binding.c frsky2way_rx_normal.c config.c rc_output.c drv_spi.c drv_ppm.c drv_sumd.c drv_sbus.c usbd_conf.c usart.c usb_device.c stm32f0xx_it.c spi.c tim.c gpio.c stm32f0xx_hal_msp.c dma.c usbd_desc.c crc.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_spi.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2c.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 4.1.0
